# Keil uVision project P02_location_gw_hal.uvprojx, settings and files
target P02_location_gw_hal (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: P02_location_gw_hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\application;..\common;..\interface\eth;..\interface\eth\w5500;..\interface\lora
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ../common/: Com_Config.h Com_Debug.c Com_Debug.h Com_Tool.c Com_Tool.h
  group interface/lora
    ../interface/lora/: driver_llcc68.c driver_llcc68.h driver_llcc68_interface.c driver_llcc68_interface.h Int_LoRa.c Int_LoRa.h
  group interface/eth
    ../interface/eth/: Int_w5500.c Int_w5500.h socket.c socket.h wizchip_conf.c wizchip_conf.h
  group interface/eth/w5500
    ../interface/eth/w5500/: dhcp.c dhcp.h dns.c dns.h httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h w5500.c w5500.h
  group application
    ../application/: App_GW.c App_GW.h
software components: CMSIS:CORE 4.3.0
